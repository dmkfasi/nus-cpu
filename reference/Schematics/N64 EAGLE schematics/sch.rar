# EAGLE board N64 (EAGLE 5.06), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
3V3  (via drill 0.3, 0.5, 0.5 pad 0.25, 0.6)  (37 unrouted)
  Top 0.254: 35.09,77.03 35.05,78.87 CD38.1 | 39.63,77.03 CD37.1 | CD34.1 53.98,81.66 53.34,81.03 53.34,75.52 U9.43 | U9.130 35.05,42.67 36.07,40.77 | U9.143 43.56,42.8 42.93,40.39 42.8,40.26 | U9.141 42.29,42.8 v42.51,41.72 42.8,40.26 | 42.8,40.26 U14.16 U11.16 | U9.148 46.86,42.67 46.1,42.67 45.47,40.26 U14.12 U11.12 | U9.152 49.4,42.67 48.13,40.26 U14.8 U11.8 | 32.51,46.1 32.48,46.1 U9.126 U14.32 U11.32 | v49.53,62.36 51.94,62.23 v53.98,64.26 55.63,64.26 56.01,63.88 57.65,63.88 U9.27 57.72,63.88 v59.44,63.88 | v59.56,70.48 57.74,70.36 U9.37 | v53.98,57.66 54.1,57.53 55.37,57.53 55.5,57.4 57.67,57.4 U9.17 | v53.98,52.45 54.48,52.45 54.74,52.2 57.67,52.2 U9.9 57.83,52.07 v60.32,52.07 | v53.98,46.86 57.68,46.86 U9.1 | U$38.31 4.45,8.86 v4.45,8.89
  Top 0.305: U9.71 35.09,77.03 | U9.64 39.63,77.03 | CD35.1 49.38,77.79 U9.49 | U9.83 23.09,71.12 CD40.1 | 22.23,67.81 U9.88 | 22.23,67.81 22.23,67.94 CD41.1 | U9.90 24.13,66.52 22.23,67.81 | U9.98 24.13,61.32 22.23,62.87 CD42.1 | U9.101 22.54,59.37 CD43.1 | U9.106 23.75,56.12 23.75,56.77 22.29,56.75 CD44.1 | U9.110 21.91,53.52 CD45.1 | U9.114 21.91,50.92 CD46.1 | U9.120 21.91,47.02 CD47.1 | v17.53,75.69 16.06,75.69 CD5.1 | v17.53,72.64 16.57,72.64 CD4.1 | v17.53,61.47 16.76,61.98 16.32,61.98 CD2.1 | v17.53,58.17 17.08,58.17 CD1.1 | CD3.1 17.27,69.09 v17.53,69.34 | CD39.1 31.24,76.96 31.24,75.52 U9.77 | CD6.1 16.95,79.82 v17.02,79.76
  Top 0.406: v35.18,46.1 35.09,46.23 U9.130 | v42.51,41.72 42.49,41.72 42.49,41.8 | v46.48,46.23 46.74,46.23 46.74,45.72 46.79,45.72 U9.148 | 32.51,46.1 v32.77,46.1 | CA10.1 57.91,9.4 v58.55,10.03 62.06,10.03 62.57,9.53 U$52.2 65.75,5.71 v68.33,5.71 | U14.1 U11.1 52.62,21.21 v54.1,21.21 | v8.38,66.17 8.38,64.39 8.89,64.39 CONT1.6 | CONT1.3 v11.94,58.33 v11.94,58.29 | v71.63,58.55 U4.15 | v68.83,69.98 U4.1 | C143.2 72.77,73.53 v72.77,71.88 | 64.9,99.31 U$37.34
  Top 1.016: 64.9,99.31 v64.9,96.14 64.9,92.71 U$37.33 | U$37.18 v44.45,96.14 U$37.17
  Top 1.27: 62.57,9.53 62.57,12.89 CA3.2 56.64,16.03 v56.64,18.67 | v55.37,22.48 54.1,22.48 v54.1,18.67 v55.37,18.67 | v55.37,18.67 v56.64,18.67 | v56.64,18.67 v56.64,19.94 | v57.91,22.48 v59.05,22.48 | v55.37,22.48 v57.91,22.48 | v55.37,22.48 v55.37,18.67 | v55.37,18.67 v56.64,18.67 | v56.64,18.67 56.64,22.22 56.9,22.48 v57.91,22.48
  Route15 0.254: 14.1,18.8 v13.21,17.91 13.21,8.89 | v4.45,8.89 13.21,8.89 | 13.21,8.89 13.21,5.59 v15.11,5.59
  Route15 0.406: v72.77,71.88 72.77,70.74 71.63,69.6
  Route15 0.61: 14.1,18.8 27.69,18.8 v27.69,26.67
  Route15 1.016: 11.94,50.93 v11.94,51.44 v11.94,58.29 | 55.24,39.62 55.88,39.75 | v11.94,58.33 11.94,66.17 v8.38,66.17 | 30.35,39.62 30.1,40.01 v30.1,37.72 30.1,26.67 v27.69,26.67 | 71.63,69.6 71.63,69.98 v68.83,69.98 68.83,92.2 v64.9,96.14 62.74,98.3 44.32,98.3 44.45,98.17 v44.45,96.14
  Route15 1.27: v55.37,22.48 55.88,22.99 v55.37,18.67 | v56.64,22.48 54.1,22.48 v54.1,18.67 v55.37,18.67 | v56.64,22.48 v59.05,22.48 59.05,21.21 v56.64,21.21 | v55.37,18.67 v56.64,18.67 v56.64,21.21 | v56.64,21.21 v56.64,22.48
  Route15 1.778: 71.63,57.15 v71.63,58.55 71.63,69.6
  Route15 2.54: 11.94,50.93 18.67,50.93 29.97,39.62 30.35,39.62 55.24,39.62 | 55.37,40.89 71.63,57.15
  Route15 3.81: 55.37,46.74 48.64,53.47 48.64,57.02 v43.56,62.1
  Route15 4.826: 55.88,22.99 55.88,39.75 55.37,40.89 55.37,46.74
  Bottom 0.254: CD14.1 53.09,80.52 51.26,80.52 U10.62 | CD15.1 54.99,77.47 53.34,75.82 51.29,75.82 U10.68 | CD16.1 54.99,74.17 53.47,72.64 U10.72 | CD17.1 54.61,70.87 53.21,69.47 51.28,69.47 U10.76 | CD18.1 54.48,67.56 53.21,66.29 51.3,66.29 U10.80 | CD20.1 54.61,60.96 53.34,62.23 | 53.34,62.23 51.28,62.23 U10.85 | CD28.1 55.28,54.23 U10.90 | v53.98,64.26 CD19.1 | v49.53,62.36 53.34,62.23 | CD31.1 59.82,63.5 v59.44,63.88 | CD33.1 60.58,70.87 60.2,70.48 v59.56,70.48 | CD29.1 54.1,57.53 v53.98,57.66 | CD27.1 52.45,51.05 v53.98,52.45 | CD30.1 59.05,50.8 v60.32,52.07 | v53.98,46.86 53.98,45.72 | C_U1.11 29.69,26.67 v27.69,26.67 | C_U1.33 13.21,18.69 v13.21,17.91 | v15.11,5.59 RE3.2
  Bottom 0.305: U10.23 18.38,75.85 v17.53,75.69 | U10.19 17.79,72.65 v17.53,72.64 | U10.5 17.8,61.45 v17.53,61.47 | U10.1 17.86,58.25 v17.53,58.17 | v17.53,69.34 19.5,69.34 U10.15 | U10.29 19.49,80.77 16.26,80.77 15.75,81.28 R29.2 | U10.32 24.76,88.27 24.13,88.9 24.13,90.24 CD7.1 | U10.36 27.96,88.12 26.92,89.15 CD8.1 | U10.40 31.16,86.95 30.61,88.14 CD9.1 | U10.44 34.36,90.29 CD10.1 | U10.49 38.36,90.23 CD11.1 | U10.60 47.16,87.46 45.72,88.9 45.72,90.24 CD13.1 | U10.54 42.36,89.72 42.42,90.17 CD12.1 | v17.02,79.76 19.52,79.76 U10.28
  Bottom 0.406: CD21.1 47.16,49.85 U10.91 | CD22.1 43.16,49.85 U10.96 | CD23.1 39.16,49.85 U10.101 | CD24.1 34.36,49.85 U10.107 | CD25.1 29.56,49.85 U10.113 | CD26.1 U10.119 | CD49.1 35.18,44.13 v35.18,46.1 | CD50.1 42.51,44 v42.51,41.72 | CD51.1 46.48,44 v46.48,46.23 | CD48.1 32.77,43.82 v32.77,46.1 | CA4.2 57.91,10.67 v58.55,10.03 | RE.1 70.04,5.71 v68.33,5.71 | R38.1 C156.2 11.87,51.5 v11.94,51.44 | C155.2 R37.1 8.38,64.96 v8.38,66.17 | C_U1.1 29.69,37.31 v30.1,37.72 | CD36.1 68.83,67.88 v68.83,69.98 | CD32.1 69.02,58.55 v71.63,58.55
  Bottom 0.61: C_U1.64 27.63,40.19 v30.1,37.72
  other vias: 32.77,66.55 34.16,66.55 35.56,66.55 36.96,66.55 36.96,65.15 35.56,65.15 34.16,65.15 32.77,65.15 32.77,59.18 32.77,60.58 34.16,60.58 34.16,59.18 35.56,60.58 35.56,59.18 36.96,59.18 36.96,60.58 42.16,64.9 43.56,64.9 43.56,63.5 42.16,63.5 42.16,62.1 42.16,60.71 43.56,60.71 55.37,21.21 54.1,19.94 55.37,19.94
  pour Bottom (isolate 0.254): 20.19,85.34 47.37,85.34 47.24,80.77 50.29,80.77 50.16,54.61 20.32,54.61
  pour Top (isolate 0.254): 26.42,74.93 56.51,74.93 56.51,44.7 26.42,44.7
  pour Route15 (isolate 0.254): 31.62,67.18 45.85,67.18 45.85,57.91 31.62,57.91
+5V  (9 unrouted)
+12V  (via drill 0.5, 0.6)  (7 unrouted)
  Route2 0.61: v46.35,4.7 46.35,2.16 60.71,2.16 v60.71,3.43
  Route2 0.813: JP2.2 83.06,3.43 v60.71,3.43
  Bottom 0.406: 56.77,3.94 CA11.1 | 61.91,12.63 3V3.7 | 59.56,3.94 59.56,5.71
  Bottom 0.61: 59.56,3.94 56.77,3.94 | 59.56,5.59 CA1.2 | 61.91,12.63 60.83,11.56 60.83,9.27 59.56,8 59.56,5.71 | 42.82,4.7 CA7.2 42.8,2.92 42.8,2.29 23.81,2.29 RE1.2 | 42.82,4.7 42.82,6.83 U12.3 | 44.89,4.7 U12.1 | 42.82,4.7 44.89,4.7 | 44.89,4.7 v46.35,4.7
  Bottom 0.813: v60.71,3.43 59.56,3.43 59.56,3.94 59.56,5.59
/COLDRESET  (via drill 0.3)  (2 unrouted)
  Top 0.254: v55.5,62.87 55.88,63.25 57.67,63.25 U9.26 | v72.39,89.28 U$37.39
  Route2 0.254: v31.88,56.39 31.88,56.77 32.77,57.66 43.18,57.66 48.9,63.37 54.99,63.37 v55.5,62.87 64.39,71.75 64.39,87.12 66.55,89.28 v72.39,89.28
  Bottom 0.254: U10.110 31.96,56.3 v31.88,56.39
/INT2  (1 unrouted)
ADJ
  Bottom 0.406: 3V3.4 71.94,10.09 RE.2 RF.1
C16X  (1 unrouted)
C_C11  (2 unrouted)
DQ0  (via drill 0.3)
  Top 0.254: v37.08,16.13 34.42,18.16 34.42,21.19 U11.29 U14.29 34.42,40.26 33.15,42.67 U9.127
  Bottom 0.254: RN1.1 38.17,15.04 v37.08,16.13
DQ1  (via drill 0.3)
  Top 0.254: v38.23,16.13 38.23,16.89 35.81,18.8 35.81,21.16 U11.27 U14.27 35.69,40.26 34.42,42.67 U9.129
  Bottom 0.254: RN1.2 38.97,15.39 v38.23,16.13
DQ2  (via drill 0.3)
  Top 0.254: v39.5,16.13 39.5,17.53 37.08,19.3 37.08,21.13 U11.25 U14.25 36.96,40.39 35.69,42.67 U9.131
  Bottom 0.254: RN1.3 39.77,15.86 v39.5,16.13
DQ3  (via drill 0.3)
  Top 0.254: v40.89,16.13 40.89,18.03 38.35,19.94 38.35,21.16 U11.23 U14.23 38.35,40.39 37.08,42.67 U9.133
  Bottom 0.254: RN1.4 40.57,15.8 v40.89,16.13
DQ4  (via drill 0.3)
  Top 0.254: v44.32,16.13 44.32,17.78 42.29,20.07 42.29,22.01 U11.17 U14.17 42.16,40.26 40.89,42.8 U9.139
  Bottom 0.254: RN2.2 45.32,15.13 v44.32,16.13
DQ5  (via drill 0.3)
  Top 0.254: v46.99,16.13 46.99,19.18 46.1,20.32 U11.11 U14.11 46.1,40.26 47.37,42.67 U9.149
  Bottom 0.254: RN2.4 46.92,16.06 v46.99,16.13
DQ6  (via drill 0.3)
  Top 0.254: U9.151 48.77,42.67 47.37,40.26 U14.9 U11.9 47.5,21.62 47.5,20.32 48.13,19.68 48.13,17.53 49.4,16.26 v49.4,16.13
  Bottom 0.254: RN3.1 49.4,16.09 v49.4,16.13
DQ7  (via drill 0.3)
  Top 0.254: U9.155 51.31,42.67 50.04,40.26 U14.5 U11.5 50.04,21.68 50.04,20.45 50.29,20.19 50.29,18.67 51.94,17.02 v51.94,16.13
  Bottom 0.254: RN3.3 52.47,15.73 v51.94,16.13
DQ8  (via drill 0.3)
  Top 0.254: U9.157 52.58,42.8 51.31,40.26 U14.3 U11.3 51.31,21.69 51.31,19.3 53.34,17.27 v53.34,16.13
  Bottom 0.254: RN3.4 53.27,16.06 v53.34,16.13
FROM_U15  (6 unrouted)
FSEL  (3 unrouted)
FSO1  (2 unrouted)
GND  (via drill 0.3, 0.3 pad 0.25, 0.5, 0.5 pad 0.25, 0.6)  (2 unrouted)
  Top 0.254: U9.55 45.48,76.69 40.13,82.04 32.89,82.04 31.12,83.82 | U9.30 60.53,65.86 64.39,69.72 64.39,71.25 64.77,71.63 | 59.82,61.85 61.34,63.37 61.34,64.01 64.01,66.67 64.52,66.67 v64.64,66.8 | v64.64,68.2 64.26,68.2 60.71,64.64 | v64.64,64.39 64.39,64.39 63.25,63.25 63.25,62.61 60.07,59.44 | 65.02,61.47 60.32,56.77 59.18,56.77 | 60.71,58.67 v65.02,62.99 | 64.64,65.53 64.26,65.53 62.36,63.63 62.36,62.99 60.07,60.71 v59.56,60.58 | 63.12,77.6 63.12,89.03 62.99,89.15 v62.99,89.28 | 62.1,76.83 62.1,88.52 v61.59,89.28 | v60.32,89.28 60.32,88.52 61.09,87.76 61.09,76.33 | v58.55,89.28 58.55,89.03 60.07,87.38 60.07,75.82 60.71,75.31 | 59.31,73.79 58.04,75.06 58.04,85.72 51.56,87.88 v51.43,89.28 | 58.42,73.15 57.02,74.55 57.02,84.96 50.42,87.25 50.42,89.41 50.16,89.41 | 47.88,86.49 55.37,83.95 v54.99,79.88 | 52.2,83.82 46.61,85.85 46.48,86.11 46.48,89.66 | 46.61,84.07 45.21,84.71 41.53,88.39 41.53,89.03 v41.27,89.28 | 45.85,79.5 40.39,84.96 35.05,84.96 34.93,85.09 v34.93,89.28 | v33.65,89.28 33.78,83.95 40.01,83.95 | 29.72,82.8 29.72,89.28 | U14.28 35.05,40.26 33.78,42.67 U9.128 33.79,43.94 33.78,43.94 33.78,46.1 v34.04,46.1 | U14.24 37.72,40.26 36.45,42.67 U9.132 36.45,43.98 36.45,45.97 36.46,46.09 | U9.134 37.72,46.09 v37.21,46.1 | v31.62,46.1 31.88,45.85 31.88,43.82 U9.125 | U9.138 40.26,42.8 41.53,40.26 U14.18 | 38.99,46.1 U9.136 38.99,42.8 40.01,40.77 38.99,42.67 | U9.140 41.66,43.99 41.53,46.1 | 40.26,46.1 40.26,43.82 | U9.145 44.83,42.67 44.2,40.26 U14.14 | U9.142 42.93,46.1 v43.05,46.23 | U9.150 48.13,42.67 46.74,40.26 U14.10 | 44.83,43.82 v44.83,46.23 | U14.22 38.99,40.26 37.72,42.55 37.72,43.94
  Top 0.254: v50.67,46.23 U9.154 50.67,43.82 50.67,42.67 49.53,40.77 | v51.94,46.23 U9.156 51.94,42.67 50.93,40.89 | v36.32,23.62 v36.32,37.08 | v40.26,23.62 v40.26,35.94 | v49.28,23.62 49.28,37.08 v49.4,37.08 | U9.8 55.24,51.57 55.24,47.62 57.68,47.62 U9.2
  Top 0.305: U9.89 27.32,67.16 27.94,66.55 27.94,65.79 26.21,65.79 U9.91
  Top 0.61: 36.46,46.09 37.72,46.09 | v37.21,46.1 38.99,46.1 40.26,46.1 v40.64,46.1 41.53,46.1
  Bottom 0.406: v47.24,81.66 49.02,81.66
  other vias: 31.5,89.28 52.71,89.28 59.82,57.02 59.82,54.36 47.62,89.28 50.16,89.28 46.35,89.28 37.46,89.15 29.84,89.28 17.78,78.87 18.67,82.93 17.53,71.12 33.78,37.08 35.05,37.08 37.59,37.08 38.99,37.08 41.53,37.08 44.2,37.08 46.74,37.08 50.67,37.08 38.99,24.89 35.05,23.62 37.59,23.62 41.53,23.62 44.2,23.62 46.74,23.62 50.67,23.62 51.94,23.62 62.23,19.68 62.23,18.03 62.23,16.38 66.8,16 66.55,8 68.2,8 69.98,8
  pour Top (isolate 0.203): 0,102.87 114.3,102.87 114.3,0 88.14,0 88.14,8.89 80.39,8.89 80.39,9.02 80.26,9.02 80.26,17.78 72.01,17.78 72.01,21.59 55.5,21.59 55.5,0 0,0 0,43.82 57.79,43.82 57.79,75.56 0,75.56
  pour Top (isolate 0.254): 0,43.82 0,75.56 25.4,75.56 25.4,43.82
  pour Bottom (isolate 0.203): 0,102.87 0,85.98 48.39,85.98 48.39,81.41 51.56,81.41 51.56,53.34 0,53.34 0,0.13 54.86,0.13 54.86,17.78 59.82,17.78 59.82,21.59 72.01,21.59 72.01,17.78 80.26,17.78 80.26,8.89 88.14,8.89 88.14,0.13 114.3,0.13 114.3,102.87
  pour Bottom (isolate 0.254): 0,85.72 19.05,85.72 19.05,53.34 0,53.34
  pour Top (isolate 0.254): 56.51,1.27 56.51,20.45 70.87,20.45 70.87,16.64 78.74,16.64 78.74,7.75 86.74,7.75 86.74,1.27
  pour Bottom (isolate 0.254): 56.01,1.27 56.01,16.51 61.09,16.51 61.09,20.45 70.74,20.45 70.74,16.64 78.74,16.64 78.74,7.75 86.74,7.75 86.74,1.27
INT0  (via drill 0.3 pad 0.25)
  Top 0.254: v29.08,73.15 29.23,73.3 U9.80
  Route15 0.254: v36.96,88.39 35.18,87.38 29.34,81.53 29.34,73.41 v29.08,73.15
  Bottom 0.254: U10.46 35.96,87.52 36.45,88.01 v36.96,88.39
LEFT_AUDIO  (2 unrouted)
N$1
  Bottom 0.406: C156.1 R54.2
N$2
  Bottom 0.406: R53.2 C155.1
N$3  (1 unrouted)
  Top 0.254: U9.11 60.75,53.52 64.52,57.28 U4.11
N$4  (1 unrouted)
N$5  (2 unrouted)
N$6  (2 unrouted)
N$7  (via drill 0.3)
  Top 0.254: v6.1,74.8 8.83,74.8 BUTT1.2
  Route2 0.254: v26.16,17.14 26.16,27.18 v21.72,31.62 | v21.72,36.58 17.4,36.58 16,37.97 9.52,37.97 6.1,41.4 v6.1,74.8
  Bottom 0.254: C_U1.20 26.19,17.11 v26.16,17.14 | v21.72,31.62 v21.72,36.58 | TVS3.1 6.1,73.09 v6.1,74.8
N$8  (1 unrouted)
N$9  (1 unrouted)
N$10  (1 unrouted)
N$11  (1 unrouted)
N$12  (1 unrouted)
N$13  (2 unrouted)
N$14  (via drill 0.3)  (6 unrouted)
  Top 0.406: CONT1.5 6.86,62.33 v6.86,61.6
  Bottom 0.406: R37.2 5.33,63.06 5.33,61.6 | 5.33,61.6 5.33,57.79 3.81,57.79 R53.1 3.81,57.91 2.03,57.91 2.03,69.98 TVS3.5 | 5.33,61.6 v6.86,61.6
N$15  (via drill 0.3)
  Top 0.254: v5.46,76.33 8.86,76.33 BUTT1.3
  Route2 0.254: v15.24,33.78 12.57,33.78 9.27,37.08 8,37.08 4.83,40.26 4.83,75.69 v5.46,76.33
  Bottom 0.254: C_U1.10 21.34,27.69 v15.24,33.78 | TVS3.6 5.46,71 v5.46,76.33
N$16  (via drill 0.5)
  Top 0.61: LED1.A 25.81,5.59 v27.05,5.59
  Bottom 0.61: v27.05,5.59 27.05,5.71 RE1.1
N$17  (via drill 0.3)  (2 unrouted)
  Top 0.254: v5.46,66.93 5.46,58.04 5.59,57.91 v6.8,56.71 7.11,56.39 8.83,56.39 CONT1.2
  Bottom 0.254: TVS3.4 5.66,67.13 v5.46,66.93 | 7.87,53.59 7.87,56.71 v6.8,56.71
  Bottom 0.406: R54.1 9.46,58.42 7.87,58.42 7.87,53.59 7.43,53.4 R38.2
N$18  (2 unrouted)
N$19  (5 unrouted)
N$20  (2 unrouted)
N$21  (5 unrouted)
N$22
  Top 0.254: U9.25 59.06,62.62 60.2,63.75 60.2,64.77 64.39,68.96 65.51,68.96 U4.2
N$23  (via drill 0.3)
  Top 0.254: U9.116 30.44,49.62 v30.73,49.91
  Route2 0.254: v30.73,49.91 31.12,49.91 v36.7,55.5
  Bottom 0.254: v36.7,55.5 36.7,53.96 U10.104
N$24  (2 unrouted)
N$25  (via drill 0.3 pad 0.25)
  Top 0.254: U9.62 40.93,72.26 v41.91,71.25
  Bottom 0.254: v41.91,71.25 41.91,67.85 U10.78
N$26  (via drill 0.3 pad 0.25)
  Top 0.254: U9.60 42.23,73.59 42.93,72.9 v44.45,72.9
  Route2 0.254: v44.45,72.9 44.45,68.83 v48.64,64.52
  Bottom 0.254: v48.64,64.52 51.13,64.52 U10.82
N$27  (4 unrouted)
N$28
  Top 0.254: U9.24 59.17,61.97 60.83,63.63 60.83,64.14 64.13,67.44 U4.3
N$29  (2 unrouted)
N$31
  Top 0.254: U9.39 59.31,71.71 59.31,73.02 57.53,74.8 57.53,85.34 50.8,87.63 50.8,96.01 49.53,97.28 U$37.22
N$32  (2 unrouted)
N$33
  Top 0.254: U9.58 43.54,77.11 39.88,80.77 30.73,80.77 29.21,82.3 U$37.5
N$34
  Top 0.254: U9.57 44.18,77.23 39.88,81.53 31.24,81.53 30.48,82.3 30.48,96.01 29.21,97.28 U$37.6
N$35
  Top 0.254: U9.54 46.13,76.8 40.26,82.68 32.89,82.68 32.26,83.31 32.26,92.08 U$37.7
N$36
  Top 0.254: U9.53 46.79,76.91 40.26,83.44 33.4,83.44 33.02,83.82 33.02,96.01 31.75,97.28 U$37.8
N$37
  Top 0.254: U9.52 47.43,77.02 45.72,78.74 45.72,78.87 40.13,84.45 34.29,84.45 U$37.9
N$38
  Top 0.254: U9.51 48.09,77.14 46.35,78.87 46.35,79.76 40.64,85.47 35.56,85.47 35.56,96.01 34.29,97.28 U$37.10
N$39  (via drill 0.3)
  Top 0.254: v28.57,60.2 28.07,60.71 26.18,60.71 U9.99
  Route15 0.254: v21.84,70.87 21.84,66.93 v28.57,60.2
  Bottom 0.254: U10.16 21.23,70.25 v21.84,70.87
N$40
  Top 0.254: U9.50 48.73,77.25 47.37,78.61 47.37,80.26 39.37,88.27 U$37.13
N$41
  Top 0.254: U9.47 50.68,81.9 50.67,82.8 45.47,83.69 40.64,88.52 40.64,96.01 39.24,97.41 39.24,99.31 U$37.14
N$42
  Top 0.254: U9.46 51.34,83.16 45.59,85.09 42.42,88.27 42.42,90.55 41.78,92.46 U$37.15
N$43
  Top 0.254: U9.45 51.98,82.76 51.94,83.44 45.97,85.47 45.97,88.65 43.18,89.79 43.18,96.01 41.78,97.41 41.78,99.31 U$37.16
N$44
  Top 0.254: U9.44 52.63,84.27 46.99,86.23 U$37.19
N$45
  Top 0.254: U9.41 54.59,76.56 55.88,77.85 55.88,84.2 48.26,86.87 48.26,96.14 46.99,97.41 U$37.20
N$46
  Top 0.254: U9.38 59.82,71.06 59.82,74.04 58.55,75.31 58.55,86.11 52.07,88.27 U$37.23
N$47
  Top 0.254: U9.35 57.79,69.21 59.82,69.21 60.83,70.1 60.83,74.42 59.56,75.69 59.56,86.87 53.47,88.9 53.47,95.88 51.94,97.41 51.94,99.31 U$37.24
N$48
  Top 0.254: U9.34 60.08,68.46 61.34,69.72 61.34,75.44 60.58,76.2 60.58,87.63 59.69,88.52 59.69,90.8 | 59.69,90.8 59.69,90.68 | 59.69,90.8 U$37.29
N$49
  Top 0.254: U9.33 60.2,67.81 61.85,69.47 61.85,76.2 61.59,76.45 61.59,88.14 60.96,88.77 60.96,96.01 59.69,97.28 U$37.30
N$50
  Top 0.254: U9.32 60.31,67.16 62.61,69.47 62.61,88.77 62.36,89.15 62.36,92.2 U$37.31
N$51
  Top 0.254: U9.31 60.42,66.52 63.12,69.21 63.12,71.25 63.5,69.21 63.5,93.34 62.23,97.28 U$37.32
N$52  (1 unrouted)
N$53  (1 unrouted)
N$54  (1 unrouted)
N$55  (1 unrouted)
N$56  (3 unrouted)
N$57
  Bottom 0.305: U10.13 19.64,67.82 21.84,67.82 22.1,67.56 22.1,64.77 21.98,64.65 U10.9 17.66,64.65 15.49,62.48 15.49,62.23 | 15.49,62.23 C8.1 | R29.1 C9.1 13.02,73.71 C5.1 10.92,71.61 10.92,60.96 11.18,60.71 14.99,60.71 15.49,61.21 15.49,62.23
N$58  (via drill 0.5)
  Top 0.305: v17.02,77.98 12.95,80.26 v12.95,83.06
  Bottom 0.305: U10.10 17.19,65.45 16.26,64.52 13.46,64.52 12.95,65.02 12.95,65.28 | 12.95,65.28 12.95,65.97 C6.1 11.94,66.04 11.94,71.12 14.73,71.12 14.99,70.87 14.99,69.34 14.73,69.09 16,69.09 | U10.14 18.61,68.65 18.29,68.33 16.76,68.33 16,69.09 | 16,69.09 15.05,69.09 C7.1 14.97,69.27 C5.2 14.97,77.42 C9.2 16.51,77.47 v17.02,77.98 | C8.2 13.02,65.21 12.95,65.28 | v12.95,83.06 13.02,83.12 R30.2
N$59
  Bottom 0.305: U10.11 15.13,66.25 C6.2
N$60
  Bottom 0.305: U10.12 16.52,67.05 16,67.56 13.46,67.56 13.21,67.82 13.21,69.03 C7.2
N$61
  Bottom 0.254: U10.24 17.09,76.65 16.51,75.56 17.4,74.3 19.44,74.3 U10.21
N$62  (1 unrouted)
  Top 0.254: U9.10 64.06,52.87
N$63  (1 unrouted)
  Top 0.254: U9.7 61.46,50.92 62.1,51.56 64.09,51.56
N$64  (1 unrouted)
  Top 0.254: U9.6 64.12,50.27
N$65  (1 unrouted)
N$66  (2 unrouted)
N$67  (2 unrouted)
N$68
  Top 0.254: U9.23 60.04,61.32 61.85,63.12 61.85,63.75 64.26,66.17 U4.4
N$69
  Top 0.254: U9.20 59.37,59.37 62.74,62.74 62.74,63.37 64.39,65.02 65.53,65.02 65.02,65.02 65.63,65.02 U4.5
N$70
  Top 0.254: U9.19 59.98,58.72 64.9,63.63 U4.6
N$71
  Top 0.254: U9.18 60.86,58.07 65.15,62.36 U4.7
N$72
  Top 0.254: U9.15 60.43,56.12 65.28,60.96 66.4,60.96 U4.8
N$73
  Top 0.254: U9.14 61.18,55.47 64.13,58.42 66.4,58.42 U4.10
N$74
  Top 0.406: U4.23 72.39,68.71 71.12,69.98 71.12,73.09 R11.2
N$75  (via drill 0.5)
  Top 0.406: U4.21 75.69,66.17 77.09,67.82 v77.09,68.71 77.34,68.89 C126.1
  Bottom 0.406: R10.2 76.26,69.53 v77.09,68.71
N$76  (via drill 0.3 pad 0.25)  (2 unrouted)
  Route15 0.254: v44.83,87.25 57.59,87.25 R34.1
  Bottom 0.254: U10.57 44.76,87.18 v44.83,87.25
N$77  (2 unrouted)
N$78  (2 unrouted)
N$79
  Top 0.406: U4.24 74.86,70.87 C143.1
N$80  (via drill 0.5)
  Top 0.406: U4.19 76.14,63.63 v77.12,64.61 77.31,64.8 C125.1
  Bottom 0.406: R9.2 75.88,65.85 v77.12,64.61
N$81  (via drill 0.5)
  Top 0.406: U4.17 v77.16,61.09 | v77.16,61.09 C124.1 | v77.16,61.09 77.22,61.09
  Bottom 0.406: R8.2 75.88,62.36 v77.16,61.09
N$82  (1 unrouted)
N$83  (2 unrouted)
N$84  (1 unrouted)
N$85  (1 unrouted)
N$86  (1 unrouted)
N$87  (1 unrouted)
N$88  (1 unrouted)
N$89  (2 unrouted)
N$90  (1 unrouted)
N$91  (1 unrouted)
N$93  (1 unrouted)
N$94  (3 unrouted)
N$95  (1 unrouted)
N$96  (via drill 0.3)
  Top 0.254: U$38.1 v8.51,38.1
  Route15 0.254: v8.51,38.1 v18.16,38.1
  Bottom 0.254: v18.16,38.1 C_U1.56
N$97  (1 unrouted)
N$98  (via drill 0.3)
  Top 0.254: U$38.2 v17.27,38.61
  Bottom 0.254: v17.27,38.61 C_U1.55
N$99  (1 unrouted)
N$100  (2 unrouted)
N$101
  Top 0.406: C124.2 80.45,62.42 83.57,65.53 83.57,72.01 82.04,73.53 82.04,75.13 U5.3
N$102
  Top 0.406: C125.2 81.41,66.04 82.3,66.93 82.3,71.5 80.77,73.02 80.77,75.1 U5.2
N$103
  Top 0.406: C126.2 80.45,71.69 79.76,72.39 79.76,75.02 U5.1
N$104  (1 unrouted)
N$105  (1 unrouted)
N$106  (1 unrouted)
N$107  (3 unrouted)
N$108  (2 unrouted)
N$109  (1 unrouted)
N$110  (1 unrouted)
N$112  (1 unrouted)
N$113  (2 unrouted)
N$114  (4 unrouted)
N$115  (1 unrouted)
N$116  (1 unrouted)
N$117  (via drill 0.3)
  Top 0.254: U$38.3 v8.51,36.07
  Route15 0.254: v8.51,36.07 v16.13,36.07
  Bottom 0.254: v16.13,36.07 C_U1.54
N$118  (via drill 0.3)
  Top 0.254: v15.11,36.83 11.17,36.83 U$38.4
  Bottom 0.254: C_U1.53 15.19,36.91 v15.11,36.83
N$119  (1 unrouted)
N$120  (via drill 0.3)
  Top 0.254: v4.45,34.93 6.57,34.93 U$38.5
  Bottom 0.254: C_U1.51 6.21,36.69 v4.45,34.93
N$121  (via drill 0.3)
  Top 0.254: U$38.6 13.91,34.86 v13.97,34.8
  Bottom 0.254: v13.97,34.8 10.8,34.8 C_U1.49
N$122  (via drill 0.3)
  Top 0.254: v4.45,32.77 6.55,32.77 U$38.7
  Bottom 0.254: C_U1.48 5.37,33.69 v4.45,32.77
N$123  (via drill 0.3)
  Top 0.254: U$38.8 13.88,32.86 v13.97,32.77
  Bottom 0.254: v13.97,32.77 10.77,32.77 C_U1.47
N$124
  Top 0.254: U9.40 57.68,72.49 56.51,73.66 56.51,84.58 49.53,86.99 U$37.21
N$125  (via drill 0.3)
  Top 0.254: v4.45,30.61 6.39,30.61 U$38.9
  Bottom 0.254: C_U1.46 5.52,31.69 v4.45,30.61
N$126  (via drill 0.3)
  Top 0.254: v4.45,28.7 6.48,28.7 U$38.11
  Bottom 0.254: C_U1.45 6.43,30.69 v4.45,28.7
N$127  (via drill 0.3)
  Top 0.254: U$38.10 12.7,30.86 v13.84,29.72
  Bottom 0.254: v13.84,29.72 10.73,29.72 C_U1.44
N$128  (via drill 0.3)
  Top 0.254: U$38.12 13.18,28.86 v13.34,28.7
  Bottom 0.254: v13.34,28.7 10.71,28.7 C_U1.43
N$129  (via drill 0.3)
  Top 0.254: v4.45,26.67 6.45,26.67 U$38.13
  Bottom 0.254: C_U1.42 5.46,27.69 v4.45,26.67
N$130  (1 unrouted)
N$131  (2 unrouted)
N$132  (via drill 0.3)
  Top 0.254: U$38.16 13.11,24.86 v14.35,23.62
  Bottom 0.254: v14.35,23.62 10.76,23.62 C_U1.38
N$133  (via drill 0.3)
  Top 0.254: U$38.18 13.08,22.86 v13.34,22.61
  Bottom 0.254: v13.34,22.61 10.77,22.61 C_U1.37
N$134  (via drill 0.3)
  Top 0.254: v4.45,22.61 6.39,22.61 U$38.17
  Bottom 0.254: C_U1.39 6.52,24.69 v4.45,22.61
N$135  (via drill 0.3)
  Top 0.254: v4.45,20.83 6.61,20.83 U$38.19
  Bottom 0.254: C_U1.36 5.3,21.69 v4.45,20.83
N$136  (1 unrouted)
N$137  (via drill 0.3)
  Top 0.254: v4.45,18.8 6.58,18.8 U$38.21
  Bottom 0.254: C_U1.34 5.34,19.69 v4.45,18.8
N$138  (via drill 0.3)
  Top 0.254: U$38.22 13.78,18.86 14.99,17.65 v15.24,17.4
  Bottom 0.254: C_U1.31 15.19,17.35 v15.24,17.4
N$139  (via drill 0.3)
  Top 0.254: v4.45,16.76 6.54,16.76 U$38.23
  Bottom 0.254: C_U1.30 16.19,18.1 16.13,18.16 14.86,18.16 13.59,16.89 4.57,16.89 v4.45,16.76
N$140  (via drill 0.3)
  Top 0.254: U$38.24 14.13,16.86 14.35,16.64 16.38,16.64 v17.14,17.4
  Bottom 0.254: v17.14,17.4 17.14,15.23 C_U1.29
N$141  (via drill 0.3)
  Top 0.254: v4.45,14.86 U$38.25
  Route2 0.254: v18.16,17.4 18.16,14.86 v4.45,14.86
  Bottom 0.254: C_U1.28 18.19,17.37 v18.16,17.4
N$142  (via drill 0.3)
  Top 0.254: v19.18,17.4 19.18,16.64 17.4,14.86 U$38.26
  Bottom 0.254: C_U1.27 19.19,17.38 v19.18,17.4
N$143  (via drill 0.3)
  Top 0.254: v4.45,12.95 4.45,12.86 U$38.27
  Route2 0.254: v20.19,17.4 20.19,12.95 v4.45,12.95
  Bottom 0.254: v20.19,17.4 C_U1.26
N$144  (via drill 0.3)
  Top 0.254: v21.21,17.4 21.21,16.51 17.53,12.83 11.17,12.83 U$38.28
  Bottom 0.254: C_U1.25 21.19,17.53 v21.21,17.4
N$145  (via drill 0.3)
  Top 0.254: v4.45,10.79 4.32,10.86 U$38.29
  Route2 0.254: v22.23,17.4 22.23,10.79 v4.45,10.79
  Bottom 0.254: C_U1.24 22.19,17.37 v22.23,17.4
N$146  (1 unrouted)
N$147
  Bottom 0.406: 3V3.2 72.83,12.63 75.18,14.99 CA12.2
N$148  (2 unrouted)
N$149  (2 unrouted)
N$150  (2 unrouted)
N$151  (2 unrouted)
N$152  (2 unrouted)
N$153  (2 unrouted)
N$157  (1 unrouted)
N$158  (1 unrouted)
N$159  (via drill 0.3)
  Top 0.254: v3.56,78.74 BUTT1.4
  Route15 0.254: v27.94,32.77 17.53,32.77 15.49,30.73 11.3,30.73 3.56,38.48 v3.56,78.74
  Bottom 0.254: C_U1.5 29.69,32.77 v27.94,32.77 | TVS5.3 9.78,77.47 9.4,77.09 6.1,77.09 5.08,78.1 4.19,78.1 v3.56,78.74
N$160  (via drill 0.3)
  Top 0.254: v3.94,80.26 8.8,80.26 BUTT1.5
  Route15 0.254: v27.3,33.66 16.76,33.66 14.86,31.75 11.81,31.75 4.83,38.74 4.83,79.38 v3.94,80.26
  Bottom 0.254: C_U1.4 27.34,33.69 v27.3,33.66 | TVS5.4 6.03,78.17 v3.94,80.26
N$161  (via drill 0.3)
  Top 0.254: v3.3,82.68 8.83,82.68 BUTT1.6
  Route2 0.254: v27.94,34.67 19.43,34.67 15.49,30.73 11.3,30.73 2.29,39.75 2.29,81.66 v3.3,82.68
  Bottom 0.254: C_U1.3 27.96,34.69 v27.94,34.67 | TVS5.5 6.35,79.12 v3.3,82.68
N$162  (via drill 0.3)
  Top 0.254: v5.21,84.58 8.73,84.58 BUTT1.7
  Route2 0.254: v27.18,35.69 18.8,35.69 14.86,31.75 11.81,31.75 3.56,40.01 3.56,77.09 5.21,78.74 v5.21,84.58
  Bottom 0.254: C_U1.2 v27.18,35.69 | TVS5.6 7.18,82.61 v5.21,84.58
N$163  (via drill 0.3)
  Top 0.254: v6.48,86.74 BUTT1.8
  Route2 0.254: v20.19,42.16 17.4,42.16 14.73,39.5 9.91,39.5 7.49,41.91 7.49,85.72 v6.48,86.74
  Bottom 0.254: v20.19,42.16 C_U1.58 | TVS5.1 9.78,83.44 v6.48,86.74
N$164  (2 unrouted)
N$165  (1 unrouted)
N$166
  Bottom 0.61: CA9.2 42.99,10.29 U12.4
N$168
  Bottom 0.406: 3V3.3 74.87,11.37 RG.1
N$170
  Bottom 0.406: 3V3.1 69.61,18.41 CA.1
N$172  (1 unrouted)
N$173  (via drill 0.5)
  Top 0.61: v15.49,9.53 16.73,9.53 LED4.A
  Bottom 0.61: RE4.1 15.49,10.16 v15.49,9.53
N$174  (via drill 0.5)
  Top 0.61: v20.19,5.59 18.83,5.59 LED3.A
  Bottom 0.61: RE3.1 v20.19,5.59
N$182  (via drill 0.3)
  other vias: 51.94,37.08
NMI  (via drill 0.3)  (1 unrouted)
  Top 0.254: v72.39,96.27 U$37.40
  Route2 0.254: v45.72,55.37 45.72,55.5 48.9,58.67 49.53,58.67 51.31,60.45 51.31,61.85 51.82,62.36 54.1,62.36 55.24,61.21 56.26,61.21 57.02,61.98 57.02,62.99 66.04,72.01 66.04,86.11 67.56,87.63 72.77,87.63 73.66,88.52 73.66,95 v72.39,96.27
  Bottom 0.254: U10.93 45.72,53.9 v45.72,55.37
OSCIN1  (2 unrouted)
OSCOUT1  (2 unrouted)
R58  (3 unrouted)
RAM0  (3 unrouted)
  Top 0.254: U9.135 38.35,42.67 39.62,40.26 U14.21 U11.21
RAM1  (via drill 0.3)
  Top 0.254: v42.93,16.13 42.93,17.53 41.02,19.56 41.02,21.8 U11.19 U14.19 40.89,40.26 39.62,42.67 U9.137
  Bottom 0.254: RN2.1 44.36,14.7 v42.93,16.13
RAM2  (1 unrouted)
  Top 0.254: U9.144 44.2,42.67 43.56,40.26 U14.15 U11.15
RAM3  (via drill 0.3)
  Top 0.254: v45.72,16.13 45.72,17.91 44.83,20.04 44.82,21.08 | 44.82,21.08 U11.13 | U9.146 45.47,42.8 44.83,40.39 U14.13 44.82,21.08
  Bottom 0.254: RN2.3 46.12,15.73 v45.72,16.13
RAM4  (via drill 0.3)
  Top 0.254: 48.64,39.1 U14.7 | 48.64,39.1 48.64,40.26 50.04,42.67 U9.153 | 48.64,39.1 U11.7 48.77,21.65 48.77,20.32 49.28,19.81 49.28,18.03 50.67,16.64 v50.67,16.13
  Bottom 0.254: RN3.2 51.67,15.13 v50.67,16.13
RIGHT_AUDIO  (2 unrouted)
SW  (1 unrouted)
  Top 0.406: U$52.1 73.57,9.34
  Top 1.27: 73.57,9.34 69.09,15.11 69.09,18.41 DA.-
  Bottom 0.406: CA.2 64.01,18.41 3V3.8
SYSAD0  (via drill 0.3 pad 0.25)
  Top 0.254: U9.66 38.34,72.39 v39.75,71.63
  Route15 0.254: v39.75,71.63 41.02,70.36 47.75,70.36 v49.02,71.5
  Bottom 0.254: v49.02,71.5 49.4,71.85 U10.73
SYSAD1  (via drill 0.3 pad 0.25)
  Top 0.254: U9.67 37.68,71.59 v37.59,71.5
  Route15 0.254: v37.59,71.5 37.59,74.3 38.73,75.44 46.86,75.44 v49.02,73.28
  Bottom 0.254: v49.02,73.28 50.04,74.3 51.21,74.3 U10.70
SYSAD2  (via drill 0.3 pad 0.25)
  Top 0.254: U9.68 37.04,70.91 v37.59,70.36
  Route2 0.254: v37.59,70.36 40.01,70.36 40.89,71.25 40.89,74.3 41.66,74.93 46.35,74.93 v48.13,73.28
  Bottom 0.254: v48.13,73.28 48.13,74.04 49.15,75.06 U10.69
SYSAD3  (via drill 0.3 pad 0.25)
  Top 0.254: U9.69 36.38,72.33 v36.32,72.26
  Route15 0.254: v36.32,72.26 36.32,77.85 37.21,78.74 v54.1,78.74
  Bottom 0.254: v54.1,78.74 52.89,77.47 U10.66
SYSAD4  (via drill 0.3 pad 0.25)
  Top 0.254: U9.72 34.43,73.64 v34.54,73.28
  Route15 0.254: v34.54,73.28 34.54,77.85 36.2,79.5 53.85,79.5 v54.1,79.76
  Bottom 0.254: v54.1,79.76 53.85,79.76 53.21,79.12 51.33,79.12 U10.64
SYSAD5  (via drill 0.3 pad 0.25)
  Top 0.254: v34.04,72.52 33.78,73.02 33.78,75.21 U9.73
  Route15 0.254: v44.2,87.88 43.69,87.25 41.91,87.25 33.78,79.12 33.78,73.02 v34.04,72.52
  Bottom 0.254: U10.56 43.96,87.01 44.2,87.25 v44.2,87.88
SYSAD6  (via drill 0.3 pad 0.25)
  Top 0.254: v33.4,71.88 33.27,72.26 33.27,75.33 U9.74
  Route15 0.254: v43.56,88.39 41.02,88.39 33.27,80.64 33.27,72.26 v33.4,71.88
  Bottom 0.254: U10.55 43.16,87.48 v43.56,88.39
SYSAD7  (via drill 0.3 pad 0.25)
  Top 0.254: v32.51,73.02 32.51,75.36 U9.75
  Bottom 0.254: U10.51 39.96,83.39 33.65,77.09 33.65,74.3 v32.51,73.02
SYSAD8  (via drill 0.3 pad 0.25)
  Top 0.254: U9.78 30.54,71.83 v30.99,71.37
  Bottom 0.254: v30.99,71.37 30.99,72.64 33.02,74.68 33.02,77.34 39.24,83.57 39.24,85.47 U10.50
SYSAD9  (via drill 0.3 pad 0.25)
  Top 0.254: v29.59,72.14 29.84,72.39 29.84,75.42 U9.79
  Route15 0.254: v36.7,87.25 36.7,85.98 31.12,80.39 31.12,74.68 29.84,73.41 29.84,72.39 v29.59,72.14
  Bottom 0.254: U10.47 36.76,87.05 v36.7,87.25
SYSAD10  (via drill 0.3 pad 0.25)
  Top 0.254: v26.92,74.17 26.13,73.38 U9.81
  Route15 0.254: v36.45,89.28 35.69,88.52 34.54,88.52 26.92,80.9 v26.92,74.17
  Bottom 0.254: U10.45 35.18,85.57 35.18,88.39 35.43,88.65 v36.45,89.28
SYSAD11  (via drill 0.3)
  Top 0.254: v28.83,70.36 26.07,70.36 U9.84
  Route2 0.254: v31.62,82.17 31.62,72.01 32,71.63 32,71.12 31.24,70.36 v28.83,70.36
  Bottom 0.254: U10.42 32.76,83.31 v31.62,82.17
SYSAD12  (via drill 0.3)
  Top 0.254: v28.19,69.72 26.18,69.72 U9.85
  Route2 0.254: v31.37,82.8 30.61,82.8 30.48,82.68 30.48,76.07 28.07,73.66 28.07,69.85 v28.19,69.72
  Bottom 0.254: U10.41 31.96,83.39 v31.37,82.8
SYSAD13  (via drill 0.3)
  Top 0.254: v29.08,69.34 28.7,69.09 26.29,69.09 U9.86
  Route15 0.254: v28.32,81.15 28.32,72.14 26.8,70.61 26.8,70.1 27.94,68.96 28.7,68.96 v29.08,69.34
  Bottom 0.254: U10.38 29.56,82.39 v28.32,81.15
SYSAD14  (via drill 0.3)
  Top 0.254: v28.57,68.33 28.45,68.45 26.15,68.45 U9.87
  Route2 0.254: v27.94,83.06 25.78,80.9 25.78,70.74 27.94,68.58 28.32,68.58 v28.57,68.33
  Bottom 0.254: U10.37 28.76,83.88 v27.94,83.06
SYSAD15  (via drill 0.3)
  Top 0.254: v29.46,65.41 29.46,65.28 29.34,65.15 26.2,65.15 U9.92
  Route15 0.254: v25.78,82.8 25.78,69.09 v29.46,65.41
  Bottom 0.254: U10.34 26.36,83.38 v25.78,82.8
SYSAD16  (via drill 0.3)
  Top 0.254: v29.97,64.77 29.72,64.52 26.18,64.52 U9.93
  Route15 0.254: v24.77,83.06 24.26,82.55 24.26,66.44 U9.93 29.77,64.56 v29.97,64.77
  Bottom 0.254: U10.33 25.56,83.85 v24.77,83.06
SYSAD17  (via drill 0.3)
  Top 0.254: v30.35,63.88 26.17,63.88 U9.94
  Bottom 0.254: U10.27 23.44,79.05 26.29,76.2 26.29,67.31 29.72,63.88 v30.35,63.88
SYSAD18  (via drill 0.3)
  Top 0.254: v28.45,63.12 28.32,63.12 28.19,63.25 26.15,63.25 U9.95
  Bottom 0.254: U10.26 22.21,78.25 25.02,75.44 25.02,66.55 v28.45,63.12
SYSAD19  (via drill 0.3)
  Top 0.254: v29.21,61.72 28.32,62.23 27.56,62.61 U9.96
  Bottom 0.254: U10.22 22.49,75.05 23.88,73.66 23.88,65.53 27.69,61.72 v29.21,61.72
SYSAD20  (via drill 0.3)
  Top 0.305: U9.102 28.49,58.72 v30.1,59.44
  Bottom 0.305: v30.1,59.44 26.8,59.44 23.11,62.99 19.67,62.99 U10.7
SYSAD21  (via drill 0.3)
  Top 0.305: U9.103 29.62,58.07 v31.24,58.17
  Bottom 0.305: v31.24,58.17 24.89,58.17 22.35,60.71 19.67,60.71 U10.4
SYSAD22  (via drill 0.3)
  Top 0.305: U9.104 28.69,57.42 v28.7,57.15
  Bottom 0.305: v28.7,57.15 27.94,57.15 27.69,57.4 24.77,57.4 22.35,59.69 19.77,59.69 U10.3
SYSAD23  (via drill 0.3)
  Top 0.254: U9.107 23.11,55.47 v23.11,56.13
  Bottom 0.254: v23.11,56.13 26.36,56.13 U10.117
SYSAD24  (via drill 0.3)
  Top 0.254: U9.108 27.56,54.82 v28.07,55.5
  Bottom 0.254: v28.07,55.5 27.96,55.5 U10.115
SYSAD25  (via drill 0.3)
  Top 0.254: U9.121 29.23,45.95 v29.21,45.97
  Route15 0.254: v29.21,45.97 29.21,52.32 38.73,52.32 38.73,52.58 v41.66,55.5
  Bottom 0.254: v41.66,55.5 41.66,54 U10.98
SYSAD26  (via drill 0.3)
  Top 0.254: U9.122 29.88,45.43 v29.84,45.47
  Route15 0.254: v29.84,45.47 29.84,51.31 40.64,51.31 v44.7,55.37
  Bottom 0.254: v44.7,55.37 44.7,53.96 U10.94
SYSAD27  (via drill 0.3)
  Top 0.254: U9.123 30.54,46.55 v30.48,46.61
  Route2 0.254: v30.48,46.61 30.48,46.86 31.12,47.5 35.05,47.5 48.13,60.58 v49.4,60.58
  Bottom 0.254: v49.4,60.58 51.19,60.58 U10.87
SYSAD28  (via drill 0.3)
  Top 0.254: U9.124 31.18,42.23 v30.99,42.04
  Route2 0.254: v30.99,42.04 34.8,42.04 53.59,60.83 53.59,60.96 v53.21,61.34
  Bottom 0.254: v53.21,61.34 51.37,61.34 U10.86
SYSAD29  (via drill 0.3 pad 0.25)
  Top 0.254: U9.59 42.88,73.79 v43.05,73.66
  Route2 0.254: v43.05,73.66 43.05,67.06 46.23,63.88 v47.75,63.88
  Bottom 0.254: v47.75,63.88 47.75,63.85 U10.83
SYSAD30  (via drill 0.3 pad 0.25)
  Top 0.254: U9.61 41.59,73.35 42.8,72.14 45.47,72.14 v45.59,72.26
  Route2 0.254: v45.59,72.26 45.59,69.72 49.15,66.17 49.15,65.79 v49.4,65.53
  Bottom 0.254: v49.4,65.53 51.18,65.53 U10.81
SYSAD31  (via drill 0.3 pad 0.25)
  Top 0.254: U9.65 38.98,73.02 v39.12,73.02
  Route15 0.254: v39.12,73.02 39.12,68.71 v48.51,68.71
  Bottom 0.254: v48.51,68.71 48.51,68.65 U10.77
SYSCMD0  (via drill 0.3)
  Top 0.254: U9.118 30.68,48.32 v30.73,48.26
  Route2 0.254: v30.73,48.26 32.77,48.26 v40.01,55.5
  Bottom 0.254: v40.01,55.5 40.01,53.95 U10.100
SYSCMD1  (via drill 0.3)
  Top 0.254: U9.117 30.68,48.97 v30.73,49.02
  Route2 0.254: v30.73,49.02 31.75,49.02 37.59,54.86 v37.59,55.5
  Bottom 0.254: v37.59,55.5 37.59,53.93 U10.103
SYSCMD2  (via drill 0.3)
  Top 0.254: U9.115 29.95,50.27 v35.18,55.5
  Bottom 0.254: v35.18,55.5 35.18,53.92 U10.106
SYSCMD3  (via drill 0.3)
  Top 0.254: U9.112 29.1,52.22 32.38,55.5 v32.77,55.5
  Bottom 0.254: v32.77,55.5 U10.109
SYSCMD4  (via drill 0.3)
  Top 0.254: U9.111 27.85,52.87 30.48,55.5 v31.12,55.5
  Bottom 0.254: v31.12,55.5 31.12,53.95 U10.111
U2  (1 unrouted)
U3  (via drill 0.3)
  Top 0.254: v40.26,36.96 U14.20 | U11.22 v38.99,24
  Route2 0.254: v40.26,36.96 39.62,36.2 39.62,24 v38.99,24
VTERM  (4 unrouted)
  Bottom 0.254: RN1.8 RN1.7 RN1.6 RN1.5 RN2.8 RN2.7 RN2.6 RN2.5 RN3.8 RN3.7 RN3.6 RN3.5
  Bottom 0.61: U12.5 44.89,10.29 46.86,10.29 | 46.86,10.29 CA8.2 | RN2.5 46.92,10.29 46.86,10.29